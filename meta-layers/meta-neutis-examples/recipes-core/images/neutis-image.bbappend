IMAGE_INSTALL_append += "qt-example"

